# Keil uVision project mon_boot_can.uvproj, settings and files
target Target 1 (MCS-51)
  device: T89C51CC01 Temic
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF) CLOCK(40000000)
  output: mon_boot_can +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: KEIL
  group Source Group 1
    ./: can_task.c lcd_drv.c lcd_task.c main.c schedule.c io_task.c
    ../../lib/: can_lib.c
    ../../isp/can/flash_api/: flash_api.c
